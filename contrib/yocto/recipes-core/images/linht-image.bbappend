# SPDX-License-Identifier: GPL-3.0-only
# Milestone 1 (D19): boot into gui_test through linht-shelld, with the launcher and Settings app.
IMAGE_INSTALL:append = " linht-platform"
